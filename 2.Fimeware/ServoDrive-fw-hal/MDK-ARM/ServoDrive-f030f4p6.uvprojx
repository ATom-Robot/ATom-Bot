# Keil uVision project ServoDrive-f030f4p6.uvprojx, settings and files
target ServoDrive-f030f4p6 (6160000::V6.16::ARMCLANG)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: ServoDrive-f030f4p6 +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F030x6,STM32F0xx,STM32F0
  c include: ../Core/Inc;     ../Drivers/STM32F0xx_HAL_Driver/Inc;     ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;     ../Drivers/CMSIS/Include;     ..\Ctrl;     ..\UserApp
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c tim.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Ctrl
    ../Ctrl/: motor.cpp motor.h random_flash_interface.h random_flash_utils.cpp random_flash_utils.h
  group UserApp
    ../UserApp/: common_inc.h configurations.h main.cpp
software components: CMSIS:CORE 5.5.0
