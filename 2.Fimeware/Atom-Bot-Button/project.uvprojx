# Keil uVision project project.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __STDC_LIMIT_MACROS, STM32F103xE, USE_HAL_DRIVER, RT_USING_LIBC, printf=rt_kprintf, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: applications\Battery;applications\APP;applications;applications\Control;applications\Debug;applications\Joint;applications\Kinematics;applications\LED;applications\Math;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\cplusplus;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;packages\cpu_usage-v1.0.0;.;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;applications\DMP_MPU6xx\eMPL;applications\DMP_MPU6xx;board;board\CubeMX_Config\Inc;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\finsh;packages\i2c-tools-latest;packages\i2c-tools-latest\src;.;rt-thread\include;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;packages\mpu6xxx-v1.1.1\inc;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\sensors;rt-thread\components\drivers\include;packages\vl53l0x-v1.0.0\inc;packages\vl53l0x-v1.0.0\vl53l0x\core\inc;packages\vl53l0x-v1.0.0\vl53l0x\platform\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\board\linker_scripts\link.sct
  group ADC-Voltage
    applications/Battery/: adc_vin_tack.c bsp_vin.c
  group app-control
    applications/APP/: app_motion_control.c
  group Applications
    applications/: main.c
  group AT-Control
    applications/Control/: bsp_motor.c bsp_encoder.c bsp_pid.c
  group AT-Debug
    applications/Debug/: ano.c
  group AT-Joint
    applications/Joint/: BSP_Joint.c
  group AT-Kinematics
    applications/Kinematics/: bsp_kinematics.c
  group AT-LED
    applications/LED/: ws2812.c ws2812b_example.c
  group AT-Math
    applications/Math/: AT_Math.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPlusPlus
    rt-thread/components/libc/cplusplus/: cxx_crt_init.c cxx_Mutex.cpp cxx_Thread.cpp cxx_crt.cpp cxx_Semaphore.cpp
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group cpu_usage
    packages/cpu_usage-v1.0.0/: cpu_usage.c cpu_usage_cmd.c
  group DeviceDrivers
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c pin.c pulse_encoder.c rt_drv_pwm.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group DMP_MPU6xx
    applications/DMP_MPU6xx/: dmp_port_rtt.c
    applications/DMP_MPU6xx/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    libraries/HAL_Drivers/: drv_adc.c drv_common.c drv_gpio.c drv_hwtimer.c drv_soft_i2c.c drv_spi.c drv_usart_v2.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group i2c-tools
    packages/i2c-tools-latest/src/: i2c_tools.cpp i2c_utils.cpp
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_spi.c stm32f1xx_hal_cortex.c stm32f1xx_hal_spi.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_crc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc.c stm32f1xx_hal.c stm32f1xx_hal_i2c.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group mpu6xxx
    packages/mpu6xxx-v1.1.1/src/: sensor_inven_mpu6xxx.c mpu6xxx.c
  group rt_kprintf
    packages/rt_vsnprintf_full/: rt_vsnprintf.c
  group Sensors
    rt-thread/components/drivers/sensors/: sensor_cmd.c sensor.c
  group vl53l0x
    packages/vl53l0x-v1.0.0/vl53l0x/core/src/: vl53l0x_api.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_calibration.c vl53l0x_api_strings.c
    packages/vl53l0x-v1.0.0/examples/: vl53l0x_sample.c
    packages/vl53l0x-v1.0.0/vl53l0x/platform/src/: vl53l0x_platform.c
    packages/vl53l0x-v1.0.0/src/: vl53l0x.c
